# Keil uVision project LCD_Driver.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LCD_Driver
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s LCD_prog.c main.c
    ../../: macros.h tm4c123gh6pm.h BITS.h
    ../Delay/: DELAY_prog.c DELAY_interface.h
    ../Switch_Driver/: SWITCH_prog.c SWITCH_config.h SWITCH_interface.h
    ../DIO_Driver_2/: DIO_prog.c DIO_interface.h
    ../PORT_Driver/: PORT_prog.c PORT_interface.h
